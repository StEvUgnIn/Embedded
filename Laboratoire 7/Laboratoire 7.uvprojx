# Keil uVision project Laboratoire 7.uvprojx, settings and files
target Target 1 (6130001::V6.13.1::.\ARMCLANG)
  device: MKL46Z256VLL4 NXP
  pack: NXP.MKL46Z4_DFP.10.0.3
  cpu: IRAM(0x1fffe000,0x8000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Laboratoire 7
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=6 wLevel=3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  group Source
    ./source/: def.h iCpu.c iCpu.h iDio.c iDio.h iPit.c iPit.h main.c main.h mCpu.c mCpu.h mDelay.c mDelay.h mLcd.c mLcd.h mLeds.c mLeds.h mSwitch.c mSwitch.h
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0
